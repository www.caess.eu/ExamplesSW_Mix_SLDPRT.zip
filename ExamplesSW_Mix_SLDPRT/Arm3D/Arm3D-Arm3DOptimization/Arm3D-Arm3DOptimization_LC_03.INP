** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,0.9999999776E-02,0.6909091026E-01,-.5954545364E-01
2,0.2099999934,0.5090909079E-01,-.5045454577E-01
3,0.2099999934,0.9999999776E-02,-.5045454577E-01
4,0.9999999776E-02,0.9999999776E-02,-.5954545364E-01
5,0.2099999934,0.9999999776E-02,0.5045454577E-01
6,0.9999999776E-02,0.9999999776E-02,0.5954545364E-01
7,0.2099999934,0.5090909079E-01,0.5045454577E-01
8,0.9999999776E-02,0.6909091026E-01,0.5954545364E-01
9,0.2099999934,0.9999999776E-02,0.000000000
10,0.2099999934,0.9999999776E-02,-.2522727288E-01
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*NODE, NSET=NSET2
254601,0.4055598301E-17,0.7000000030E-01,0.5999999866E-01
254602,0.000000000,0.000000000,-.5999999866E-01
254604,0.000000000,0.000000000,0.5999999866E-01
254606,0.000000000,0.7000000030E-01,-.5999999866E-01
254609,0.000000000,0.000000000,0.000000000
254610,0.000000000,0.000000000,0.2999999933E-01
254611,0.000000000,0.000000000,-.2999999933E-01
254612,0.000000000,0.000000000,0.4500000179E-01
254613,0.000000000,0.000000000,0.1499999966E-01
254614,0.000000000,0.000000000,-.1499999966E-01
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,7619,7620,7621,7622,56523,56524,56525,56526,56527,56528
2,7623,7624,7625,7626,56529,56530,56531,56532,56533,56534
3,7627,7628,7629,7630,56535,56536,56537,56538,56539,56540
4,7627,7631,7632,7633,56541,56542,56543,56544,56545,56546
5,7627,7631,7634,7635,56541,56547,56548,56549,56550,56551
6,7627,7630,7635,7636,56538,56552,56549,56553,56554,56555
7,7637,7638,7639,7640,56556,56557,56558,56559,56560,56561
8,7641,7642,7643,7644,56562,56563,56564,56565,56566,56567
9,7641,7645,7646,7647,56568,56569,56570,56571,56572,56573
10,7641,7648,7647,7642,56574,56575,56571,56562,56576,56577
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
179638,260379,260380,260381,260382,287645,287646,287647,287648,287649,287650
179639,260379,260380,260383,260384,287645,287651,287652,287653,287654,287655
179640,260379,260385,260381,260386,287656,287657,287647,287658,287659,287660
179641,260379,260380,260384,260386,287645,287654,287653,287658,287661,287662
179642,260387,260388,260389,260390,287663,287664,287665,287666,287667,287668
179643,260387,260391,260388,260390,287669,287670,287663,287666,287671,287667
179644,260392,260393,260394,260387,287672,287673,287674,287675,287676,287677
179645,260387,260389,260388,260395,287665,287664,287663,287678,287679,287680
179646,260396,260397,260398,260399,287681,287682,287683,287684,287685,287686
179647,260400,260396,260401,260402,287687,287688,287689,287690,287691,287692
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
254601,254602,254604,254606,254609,254610,254611,254612,254613,254614,254615,254616,254617,254618,254619,254620,
254621,254622,254623,254624,254625,254626,254627,254628,254629,254630,254631,254632,254633,254634,254635,254636,
254637,254638,254639,254702,254703,254704,254705,254706,254707,254708,254709,254710,254711,254712,254713,254714,
254715,254716,254717,254718,254719,254720,254721,254722,254723,254724,254725,254726,254727,254728,254729,254730,
254731,254732,254733,254734,254735,254736,254737,254738,254739,254740,254741,254742,254743,254744,254745,254746,
254747,254748,254749,254750,254751,254752,254753,254754,254755,254756,254757,254758,254759,254760,254761,254762,
254763,254764,254765,254766,254767,254768,254769,254770,254771,254772,254773,254774,254775,254776,254777,254778,
254779,254780,254781,254782,254783,254784,254785,254786,254787,254788,254789,254790,254791,254792,254793,254794,
257739,257740,257741,257742,257743,257744,257745,257746,257747,257748,257749,257750,257751,257752,257753,257754,
257755,257756,257757,257758,257759,257760,257761,257762,257763,257764,257765,257766,257767,257768,257769,257770,
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*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
254603
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
254605
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
254607
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
254608
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
254801
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
254802
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
254803
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
254804
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
254805
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
254806
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
254807
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
254808
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
254809
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
254810
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
254811
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
254812
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
254813
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
254814
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
254815
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
254885
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
254886
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
254887
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
254888
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
254889
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
254890
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
254891
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
254892
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
254893
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
254894
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
254895
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
254896
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
254897
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
254898
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
254899
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
270258
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
270259
*NSET,NSET=CL_NSET37,INSTANCE=PART1-1
270260
*NSET,NSET=CL_NSET38,INSTANCE=PART1-1
270261
*NSET,NSET=CL_NSET39,INSTANCE=PART1-1
270262
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
*CLOAD,OP=NEW
CL_NSET1,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET2,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET3,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET4,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET5,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET6,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET7,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET8,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET9,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET10,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET11,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET12,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET13,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET14,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET15,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET16,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET17,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET18,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET19,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET20,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET21,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET22,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET23,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET24,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET25,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET26,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET27,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET28,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET29,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET30,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET31,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET32,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET33,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET34,2,-0.121212E+04
*CLOAD,OP=NEW
CL_NSET35,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET36,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET37,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET38,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET39,2,0.121212E+04
*CLOAD,OP=NEW
CL_NSET40,2,0.121212E+04
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*END STEP
