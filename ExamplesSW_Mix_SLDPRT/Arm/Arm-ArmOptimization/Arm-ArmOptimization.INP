** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,0.5312500056E-02,0.3492283449E-01,-.4999999888E-02
2,0.4830591846E-02,0.3458540142E-01,-.4999999888E-02
3,0.4414599854E-02,0.3416940942E-01,-.4999999888E-02
4,0.4077164456E-02,0.3368749842E-01,-.4999999888E-02
5,0.3828537418E-02,0.3315431625E-01,-.4999999888E-02
6,0.3676273860E-02,0.3258606419E-01,-.4999999888E-02
7,0.3624999896E-02,0.3200000152E-01,-.4999999888E-02
8,0.3676273860E-02,0.3141393885E-01,-.4999999888E-02
9,0.3828537418E-02,0.3084568121E-01,-.4999999888E-02
10,0.4077164456E-02,0.3031250089E-01,-.4999999888E-02
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*NODE, NSET=NSET2
8064,0.1449999958E-01,0.4199999943E-01,0.000000000
8065,0.1438302267E-01,0.4167860746E-01,0.000000000
8066,0.1408682391E-01,0.4150759429E-01,0.000000000
8067,0.1374999993E-01,0.4156698659E-01,0.000000000
8068,0.1374999993E-01,0.4156698659E-01,0.5555555690E-03
8069,0.1374999993E-01,0.4156698659E-01,0.1111111138E-02
8070,0.1374999993E-01,0.4156698659E-01,0.1666666707E-02
8071,0.1374999993E-01,0.4156698659E-01,0.2222222276E-02
8072,0.1374999993E-01,0.4156698659E-01,0.2777777845E-02
8073,0.1374999993E-01,0.4156698659E-01,0.3333333414E-02
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
847683,0.1449999958E-01,0.4199999943E-01,-.4999999888E-02
847684,0.1438302267E-01,0.4167860746E-01,-.4999999888E-02
847685,0.1408682391E-01,0.4150759429E-01,-.4999999888E-02
847686,0.1374999993E-01,0.4156698659E-01,-.4999999888E-02
847687,0.1374999993E-01,0.4156698659E-01,-.4444444552E-02
847688,0.1374999993E-01,0.4156698659E-01,-.3888888983E-02
847689,0.1374999993E-01,0.4156698659E-01,-.3333333414E-02
847690,0.1374999993E-01,0.4156698659E-01,-.2777777845E-02
847691,0.1374999993E-01,0.4156698659E-01,-.2222222276E-02
847692,0.1374999993E-01,0.4156698659E-01,-.1666666707E-02
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*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET4
460313,0.7499999832E-02,0.3200000152E-01,-.4999999888E-02
460314,0.7383021992E-02,0.3167860582E-01,-.4999999888E-02
460315,0.7086824160E-02,0.3150759637E-01,-.4999999888E-02
460316,0.6750000175E-02,0.3156698868E-01,-.4999999888E-02
460317,0.6750000175E-02,0.3156698868E-01,-.4444444552E-02
460318,0.6750000175E-02,0.3156698868E-01,-.3888888983E-02
460319,0.6750000175E-02,0.3156698868E-01,-.3333333414E-02
460320,0.6750000175E-02,0.3156698868E-01,-.2777777845E-02
460321,0.6750000175E-02,0.3156698868E-01,-.2222222276E-02
460322,0.6750000175E-02,0.3156698868E-01,-.1666666707E-02
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*TRANSFORM,TYPE=R,NSET=NSET4
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,
*NODE, NSET=NSET5
839070,0.6750000175E-02,0.3156698868E-01,0.5555555690E-03
839071,0.6750000175E-02,0.3156698868E-01,0.1111111138E-02
839072,0.6750000175E-02,0.3156698868E-01,0.1666666707E-02
839073,0.6750000175E-02,0.3156698868E-01,0.2222222276E-02
839074,0.6750000175E-02,0.3156698868E-01,0.2777777845E-02
839075,0.6750000175E-02,0.3156698868E-01,0.3333333414E-02
839076,0.6750000175E-02,0.3156698868E-01,0.3888888983E-02
839077,0.6750000175E-02,0.3156698868E-01,0.4444444552E-02
839078,0.6750000175E-02,0.3156698868E-01,0.4999999888E-02
839079,0.7086824160E-02,0.3150759637E-01,0.4999999888E-02
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*TRANSFORM,TYPE=R,NSET=NSET5
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,486,480,153,160,1108,2720,2719,2669,2670,2724
2,169,170,497,163,2608,2599,2603,2646,2645,2642
3,482,156,155,162,2697,2710,2704,2654,2701,2708
4,164,165,485,158,2641,2628,2637,2685,2684,2680
5,164,497,498,171,2634,1051,2633,2639,2595,2594
6,163,156,157,483,2700,2702,2694,2644,2696,2690
7,499,136,475,474,2836,2837,1122,1124,2838,1126
8,473,492,165,485,1127,2626,2630,1128,1083,2628
9,165,485,158,473,2628,2680,2684,2630,1128,2681
10,135,136,475,499,2846,2837,2842,2841,2836,1122
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
3806,8594,8595,8596,8597,13177,13164,13176,13175,13163,13149
3807,8595,8594,8596,8598,13177,13176,13164,13162,13174,13148
3808,8599,8600,8601,8594,13121,13108,13120,13173,13172,13171
3809,8594,8595,8597,8602,13177,13163,13175,13170,13161,13138
3810,8603,8595,8598,8604,13160,13162,13129,13077,13159,13128
3811,8595,8598,8604,8594,13162,13128,13159,13177,13174,13169
3812,8594,8595,8602,8605,13177,13161,13170,13168,13158,13088
3813,8594,8595,8605,8604,13177,13158,13168,13169,13159,13069
3814,8606,8607,8608,8609,13046,13034,13045,13044,13033,13019
3815,8606,8610,8611,8612,13043,12998,13042,13041,12997,12986
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
9559,17101,17102,17108,17381,18310,18302,18309,18304,18296,18247
9560,17368,17101,17374,17375,18307,18306,17455,17454,18305,17439
9561,17382,17103,17383,17376,18287,18286,17418,17433,18289,17432
9562,17381,17109,17108,17388,18242,18250,18247,17419,18240,18246
9563,17369,17368,17375,17102,17456,17454,17452,18299,18300,18298
9564,16953,134,135,475,19531,2854,19532,19282,2851,2842
9565,17244,16953,16947,16946,19281,19330,19325,19332,19336,19337
9566,16954,16960,17245,16961,19279,19241,19276,19278,19247,19234
9567,16946,17244,475,474,19332,17889,19335,19334,17886,1126
9568,474,16946,136,475,19334,19534,2838,1126,19335,2837
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
11307,21405,21406,21407,21408,25084,25075,25083,25082,25074,25068
11308,21405,21409,21410,21411,25081,25052,25080,25079,25051,25044
11309,21405,20766,21406,21412,29017,29016,25084,25078,29015,25073
11310,21405,20767,21412,21413,29010,29008,25078,25077,29007,25033
11311,21405,21410,20774,21411,25080,28972,28973,25079,25044,28971
11312,21414,21415,21416,21417,25020,25011,25019,25018,25010,25003
11313,21414,21418,21419,21420,25017,24988,25016,25015,24987,24981
11314,21414,21419,21421,20811,25016,24980,25014,28727,28726,28725
11315,21414,21415,21417,20812,25020,25010,25018,28722,28721,28720
11316,21414,21421,20812,20811,25014,28719,28722,28727,28725,28728
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
18405,32335,32334,32643,32327,33896,33892,33886,33942,33943,33939
18406,32261,32582,32581,32589,34340,33018,34341,34339,33015,33016
18407,32588,32260,32259,32580,34345,34357,34351,33019,34347,34353
18408,32253,32573,32252,32581,34394,34400,34404,34392,33038,34398
18409,32582,32186,32519,32518,34848,34849,33186,33190,34850,33191
18410,32572,32252,32580,32251,34401,34399,33041,34407,34411,34405
18411,32251,32252,32244,32572,34411,34456,34457,34407,34401,34453
18412,32581,32252,32580,32573,34398,34399,33021,33038,34400,33039
18413,32530,32572,32244,32573,33149,34453,34454,33148,33043,34452
18414,32319,32326,32327,32635,34026,33952,34025,34019,33947,33941
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
20177,36059,36060,36061,36062,42779,42764,42778,42777,42763,42753
20178,36059,36063,36064,36065,42776,42731,42775,42774,42730,42718
20179,36059,36064,36066,36067,42775,42717,42773,42772,42716,42695
20180,36059,36062,36068,36069,42777,42741,42771,42770,42740,42671
20181,36070,36071,36072,36073,42648,42636,42647,42646,42635,42623
20182,36070,36074,36071,36075,42645,42634,42648,42644,42601,42633
20183,36070,36075,36076,36077,42644,42590,42643,42642,42589,42576
20184,36078,36079,36080,36081,42561,42545,42560,42559,42544,42533
20185,36078,36082,36083,36084,42558,42510,42557,42556,42509,42495
20186,36078,36085,36081,36080,42555,42522,42559,42560,42532,42533
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
28015,47016,47017,46996,47018,50696,51093,51094,50695,50689,51092
28016,47016,47019,46995,46991,50694,51098,51100,51121,51120,51122
28017,47016,47017,46992,46996,50696,51114,51115,51094,51093,51116
28018,47020,47021,47022,46727,50678,50668,50677,52771,52770,52769
28019,47020,46581,46734,46735,53878,53880,52731,52727,53879,52732
28020,47020,47021,47023,47024,50678,50667,50676,50675,50666,50652
28021,47025,46581,46734,47020,53877,53880,52729,50674,53878,52731
28022,47026,46619,47027,47028,53554,53553,50629,50628,53552,50620
28023,47023,47029,47030,47025,50650,50605,50649,50651,50639,50638
28024,47031,47020,47025,47029,50672,50674,50637,50604,50673,50639
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
35122,57388,57672,57387,57680,59412,59418,59422,59410,58114,59416
35123,57681,57321,57618,57617,59865,59866,58262,58266,59867,58267
35124,57671,57387,57679,57386,59419,59417,58117,59425,59429,59423
35125,57386,57387,57379,57671,59429,59474,59475,59425,59419,59471
35126,57680,57387,57679,57672,59416,59417,58097,58114,59418,58115
35127,57629,57671,57379,57672,58225,59471,59472,58224,58119,59470
35128,57450,57723,57724,57442,58986,57956,58985,59066,59061,59060
35129,57449,57457,57731,57730,58994,58937,58990,58991,58938,57937
35130,57678,57394,57393,57386,59372,59382,59378,59424,59427,59428
35131,57686,57394,57393,57678,59370,59382,59376,58098,59372,59378
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
36895,61231,61232,61233,61234,67962,67948,67961,67960,67947,67944
36896,61231,61235,61236,61237,67959,67926,67958,67957,67925,67913
36897,61231,61238,61235,61237,67956,67924,67959,67957,67898,67925
36898,61239,61238,61240,61236,67885,67884,67874,67911,67912,67910
36899,61238,61240,61236,61231,67884,67910,67912,67956,67955,67958
36900,61235,61241,61238,61231,67923,67883,67924,67959,67954,67956
36901,61242,61235,61241,61238,67922,67923,67863,67882,67924,67883
36902,61231,61238,61243,61241,67956,67881,67953,67954,67883,67862
36903,61231,61243,61234,61244,67953,67932,67960,67952,67839,67931
36904,61245,61246,61247,61248,67828,67816,67827,67826,67815,67805
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
44722,72206,32573,72198,72199,73626,73629,72309,72307,73628,72311
44723,32580,72197,72205,32573,73597,72312,73595,33039,73630,73627
44724,32580,32572,32579,72204,33041,33042,33024,73596,73633,73599
44725,72204,32578,72203,32571,73602,73603,72298,73638,33045,73639
44726,72203,32571,72196,72204,73639,73640,72316,72298,73638,72315
44727,72196,32572,32571,72154,73635,33046,73640,72427,73637,73642
44728,32573,72206,72205,32580,73626,72292,73627,33039,73594,73595
44729,72204,32587,32579,32580,73567,33022,73599,73596,33020,33024
44730,72204,32572,32571,72196,73633,33046,73638,72315,73635,73640
44731,32581,72214,32589,32582,73588,73555,33016,33018,73584,33015
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
53875,83817,83818,32624,32690,84950,87228,87229,86960,86959,32912
53876,83817,83819,32683,32623,84949,86987,86988,87234,87233,32915
53877,83817,83819,83778,83631,84949,85072,85073,85892,85890,85893
53878,83817,83819,83712,83820,84949,85376,85378,84948,84944,85375
53879,83817,83631,83818,83712,85892,85891,84950,85378,85896,85377
53880,83821,83818,83719,83822,84946,85329,85327,84936,84945,85326
53881,83821,83818,83776,83719,84946,85078,85077,85327,85329,85330
53882,83821,83733,83823,83726,85231,85230,84935,85279,85282,85277
53883,32172,32206,83792,32173,34938,86334,86419,34940,34932,86418
53884,83776,83726,83775,83821,85280,85281,85082,85077,85279,85081
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
58007,3755,20827,3756,3831,83254,83253,7848,7846,90632,7841
58008,3756,46652,3838,3831,90339,90335,7840,7841,90336,7336
58009,46589,3824,46588,46638,90599,90601,53773,53761,90404,53769
58010,46736,89327,3945,3952,89963,89351,89966,89965,89350,6592
58011,46729,46574,3768,46575,53940,90666,90001,53934,53942,90663
58012,3823,3831,46637,3824,7387,90406,90408,7389,7382,90407
58013,4409,46485,46484,46492,89644,54522,89645,89643,54514,54520
58014,46492,4408,46484,4409,89649,89650,54520,89643,4673,89645
58015,46583,3729,3818,3730,90621,8024,90617,90620,8025,8016
58016,3953,46744,46736,46737,89926,52721,89964,89958,52714,52723
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG4
60090,103804,103805,103806,103807,360912,360899,360911,360910,360898,360883
60091,103804,103807,103808,103805,360910,360871,360909,360912,360898,360897
60092,103804,103809,103810,103806,360908,360849,360907,360911,360882,360881
60093,103804,103808,103811,103812,360909,360860,360906,360905,360859,360827
60094,103813,103814,103815,103816,360809,360792,360808,360807,360791,360781
60095,103813,103817,103818,103819,360806,360755,360805,360804,360754,360742
60096,103813,103820,103821,103822,360803,360719,360802,360801,360718,360707
60097,103813,103823,103824,103825,360800,360683,360799,360798,360682,360675
60098,103813,103826,103821,103820,360797,360706,360802,360803,360716,360719
60099,103813,103814,103817,103824,360809,360790,360806,360799,360789,360753
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
315586,456231,32625,456232,57771,459240,459239,457350,458907,58043,458906
315587,456231,57764,83778,32624,458936,458937,457476,459238,58041,87230
315588,456231,456232,91160,456233,457350,457666,457667,457349,457346,457665
315589,456231,456232,83632,91160,457350,457999,458000,457667,457666,452443
315590,456231,91153,83632,83631,457683,452444,458000,458001,452448,85897
315591,456231,83778,91153,83631,457476,457684,457683,458001,85893,452448
315592,456234,57736,32618,83768,459054,58029,459233,457497,459055,87249
315593,456234,456235,91118,83623,457339,457821,457822,458009,458008,452492
315594,456234,456236,91118,456235,457338,457820,457822,457339,457335,457821
315595,456234,32618,57736,57743,459233,58029,459054,459026,58028,57920
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
319704,460516,460517,460518,460519,465073,465061,465072,465071,465060,465048
319705,460516,460520,460521,460522,465070,465031,465069,465068,465030,465017
319706,460516,460522,460523,460520,465068,465005,465067,465070,465030,465029
319707,460524,424,460525,382,467026,467025,464981,467202,1361,467201
319708,460526,460527,460528,460529,464965,464954,464964,464963,464953,464936
319709,460526,460528,460530,460531,464964,464935,464962,464961,464934,464913
319710,460526,460532,460531,460530,464960,464897,464961,464962,464912,464913
319711,460526,460533,460534,460532,464959,464872,464958,464960,464885,464884
319712,460535,460536,460537,460538,464852,464842,464851,464850,464841,464835
319713,460539,460540,460541,460542,464814,464803,464813,464812,464802,464787
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG5
325438,475359,475360,475361,475362,755382,755369,755381,755380,755368,755358
325439,475359,475362,475363,475364,755380,755348,755379,755378,755347,755337
325440,475359,475361,475365,475366,755381,755357,755377,755376,755356,755317
325441,475359,475367,475362,475361,755375,755346,755380,755381,755355,755358
325442,475359,475364,475368,475369,755378,755328,755374,755373,755327,755282
325443,475370,475371,475372,475373,755259,755247,755258,755257,755246,755236
325444,475370,475374,475372,475375,755256,755235,755258,755255,755212,755234
325445,475370,475376,475377,475378,755254,755189,755253,755252,755188,755175
325446,475370,475377,475376,475379,755253,755189,755254,755251,755174,755187
325447,475370,475374,475375,475376,755256,755212,755255,755254,755211,755201
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
596324,834754,468106,468074,834776,838310,829419,838504,835972,838309,838502
596325,834776,834777,834778,468106,835907,835903,835906,838309,838308,838307
596326,834777,834776,834755,468074,835907,835969,835968,838501,838502,838503
596327,834776,834778,74552,834779,835906,836900,836901,835905,835900,836899
596328,468099,468106,468075,834754,829172,829412,829413,838340,838310,838500
596329,834780,834781,834764,467864,835891,835941,835942,836447,836446,836448
596330,834780,74661,74625,834764,837726,74955,837912,835942,837727,837913
596331,834780,834782,467871,834783,835890,836419,836420,835889,835883,836418
596332,834780,834784,467871,467806,835888,836417,836420,836629,836628,833190
596333,834780,834782,834781,467864,835890,835887,835891,836447,836445,836446
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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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG3,MATERIAL=MAT3, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG4,MATERIAL=MAT4, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG5,MATERIAL=MAT5, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
8064,8065,8066,8067,8068,8069,8070,8071,8072,8073,8074,8075,8076,8077,8078,8079,
8080,8081,8082,8083,8084,8085,8086,8087,8088,8089,8090,8091,8092,8093,8094,8095,
8096,8097,8098,8099,8100,8101,8102,8103,8104,8105,8106,8107,8108,8109,8110,8111,
8112,8113,8114,8115,8443,8444,8445,8446,8447,8448,8449,8450,8451,8452,8453,14101,
14110,14117,14118,14126,14135,14140,14146,14147,14152,14156,14157,16390,16399,16406,16407,16415,
16421,16426,16430,16431,16436,16437,16442,16443,16444,16445,16446,16452,16453,16454,16455,16456,
16465,16466,16467,16468,16469,16477,16478,16479,16480,16481,16489,16490,16491,16492,16493,16497,
16498,16499,16500,16501,16511,16512,16513,16514,16515,16522,16523,16524,16525,16530,16531,16536,
16537,16538,16544,16545,16556,16565,16572,16573,16581,16589,16594,16595,16596,16604,16605,16606,
16607,16608,16615,16616,16617,16618,16619,16626,16627,16628,16629,16630,16638,16639,16640,16641,
16642,16650,16651,16652,16653,16654,16662,16663,16664,16665,16666,16672,16673,16674,16675,16678,
16679,16684,16685,16686,16690,16691,16696,16697,16700,16701,16702,16703,16704,16712,16713,16714,
16715,16716,16723,16724,16725,16726,16727,16735,16736,16737,16738,16739,16748,16749,16750,16751,
16752,16756,16757,16758,16759,16760,16771,16772,16773,16774,16775,16781,16782,16783,16784,16788,
16789,16795,16796,16797,16802,16803,16804,16810,16811,16812,
*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
460313,460314,460315,460316,460317,460318,460319,460320,460321,460322,460323,460324,460325,460326,460327,460328,
460329,460330,460331,460332,460333,460334,460335,460336,460337,460338,460339,460340,460341,460342,460343,460344,
460345,460346,460347,460348,460349,460350,460351,460352,460353,460354,460355,460356,460357,460358,460359,460360,
460361,460362,460363,460364,460365,460366,460367,460368,460369,460370,460371,460372,460373,460374,460375,465993,
466003,466010,466011,466021,466029,466034,466037,466038,466043,466047,466048,467371,467382,467389,467390,467397,
467405,467410,467414,467415,467421,467422,467426,467427,467428,467429,467430,467437,467438,467439,467440,467441,
467449,467450,467451,467452,467453,467460,467461,467462,467463,467464,467473,467474,467475,467476,467477,467483,
467484,467485,467486,467487,467494,467495,467496,467497,467498,467504,467505,467506,467507,467512,467513,467517,
467518,467519,467523,467524,467534,467545,467552,467553,467562,467570,467578,467579,467580,467588,467589,467590,
467591,467592,467599,467600,467601,467602,467603,467610,467611,467612,467613,467614,467623,467624,467625,467626,
467627,467634,467635,467636,467637,467638,467647,467648,467649,467650,467651,467657,467658,467659,467660,467665,
467666,467671,467672,467673,467677,467678,467683,467684,467692,467693,467694,467695,467696,467704,467705,467706,
467707,467708,467713,467714,467715,467716,467717,467726,467727,467728,467729,467730,467739,467740,467741,467742,
467743,467749,467750,467751,467752,467753,467763,467764,467765,467766,467767,467772,467773,467774,467775,467780,
467781,467787,467788,467789,467793,467794,467795,467800,467801,467802,
*NSET,NSET=BC_NSET3,INSTANCE=PART1-1
839070,839071,839072,839073,839074,839075,839076,839077,839078,839079,839080,839081,839082,839083,839084,839085,
839086,839087,839088,839089,839090,839091,839092,839093,839094,839095,839096,839097,839098,839099,839100,839101,
839102,839103,839104,839105,839106,839107,839108,839109,839110,839111,839112,839113,839114,839115,839116,839117,
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*NSET,NSET=BC_NSET4,INSTANCE=PART1-1
847683,847684,847685,847686,847687,847688,847689,847690,847691,847692,847693,847694,847695,847696,847697,847698,
847699,847700,847701,847702,847703,847704,847705,847706,847707,847708,847709,847710,847711,847712,847713,847714,
847715,847716,847717,847718,847719,847720,847721,847722,847723,847724,847725,847726,847727,847728,847729,847730,
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*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
35804
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
35805
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
35806
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
35807
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
35808
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
35809
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
35810
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
35811
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
35812
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
35813
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
35814
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
35815
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
35816
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
35817
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
35818
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
35819
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
35820
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
35821
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
35822
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
35823
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
35824
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
35825
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
35826
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
35827
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
35828
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
35829
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
35830
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
35831
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
35832
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
35833
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
35834
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
35835
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
35836
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
35837
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
35838
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
35839
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT3
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT4
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT5
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,3,3
ASSEMBLY.BC_NSET3,3,3
ASSEMBLY.BC_NSET4,1,1
ASSEMBLY.BC_NSET4,2,2
ASSEMBLY.BC_NSET4,3,3
*CLOAD,OP=NEW
CL_NSET1,2,-0.163675E+00
*CLOAD,OP=NEW
CL_NSET2,2,-0.157883E+00
*CLOAD,OP=NEW
CL_NSET3,2,-0.157867E+00
*CLOAD,OP=NEW
CL_NSET4,2,-0.163693E+00
*CLOAD,OP=NEW
CL_NSET5,2,-0.929994E+00
*CLOAD,OP=NEW
CL_NSET6,2,-0.108741E+01
*CLOAD,OP=NEW
CL_NSET7,2,-0.108397E+01
*CLOAD,OP=NEW
CL_NSET8,2,-0.108397E+01
*CLOAD,OP=NEW
CL_NSET9,2,-0.108396E+01
*CLOAD,OP=NEW
CL_NSET10,2,-0.108397E+01
*CLOAD,OP=NEW
CL_NSET11,2,-0.108746E+01
*CLOAD,OP=NEW
CL_NSET12,2,-0.929963E+00
*CLOAD,OP=NEW
CL_NSET13,2,-0.327341E+00
*CLOAD,OP=NEW
CL_NSET14,2,-0.315719E+00
*CLOAD,OP=NEW
CL_NSET15,2,-0.371188E+00
*CLOAD,OP=NEW
CL_NSET16,2,-0.327308E+00
*CLOAD,OP=NEW
CL_NSET17,2,-0.679832E+00
*CLOAD,OP=NEW
CL_NSET18,2,-0.113632E+01
*CLOAD,OP=NEW
CL_NSET19,2,-0.108367E+01
*CLOAD,OP=NEW
CL_NSET20,2,-0.108365E+01
*CLOAD,OP=NEW
CL_NSET21,2,-0.108366E+01
*CLOAD,OP=NEW
CL_NSET22,2,-0.108367E+01
*CLOAD,OP=NEW
CL_NSET23,2,-0.108703E+01
*CLOAD,OP=NEW
CL_NSET24,2,-0.929820E+00
*CLOAD,OP=NEW
CL_NSET25,2,-0.125283E+01
*CLOAD,OP=NEW
CL_NSET26,2,-0.105870E+01
*CLOAD,OP=NEW
CL_NSET27,2,-0.108384E+01
*CLOAD,OP=NEW
CL_NSET28,2,-0.108385E+01
*CLOAD,OP=NEW
CL_NSET29,2,-0.130972E+01
*CLOAD,OP=NEW
CL_NSET30,2,-0.108386E+01
*CLOAD,OP=NEW
CL_NSET31,2,-0.130972E+01
*CLOAD,OP=NEW
CL_NSET32,2,-0.157862E+00
*CLOAD,OP=NEW
CL_NSET33,2,-0.157878E+00
*CLOAD,OP=NEW
CL_NSET34,2,-0.163687E+00
*CLOAD,OP=NEW
CL_NSET35,2,-0.930004E+00
*CLOAD,OP=NEW
CL_NSET36,2,-0.108746E+01
*CLOAD,OP=NEW
CL_NSET37,2,-0.108401E+01
*CLOAD,OP=NEW
CL_NSET38,2,-0.108401E+01
*CLOAD,OP=NEW
CL_NSET39,2,-0.108400E+01
*CLOAD,OP=NEW
CL_NSET40,2,-0.108401E+01
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*END STEP
