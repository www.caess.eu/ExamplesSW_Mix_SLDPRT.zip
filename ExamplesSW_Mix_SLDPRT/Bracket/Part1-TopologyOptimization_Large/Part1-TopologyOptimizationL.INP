** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
211,0.4399999976E-01,0.1896223426E-01,0.9499999695E-02
212,0.4300697893E-01,0.1896223426E-01,0.9447958320E-02
213,0.4202483967E-01,0.1896223426E-01,0.9292402305E-02
214,0.4106433690E-01,0.1896223426E-01,0.9035036899E-02
215,0.4013600200E-01,0.1896223426E-01,0.8678682148E-02
216,0.3925000131E-01,0.1896223426E-01,0.8227241226E-02
217,0.3841603920E-01,0.1896223426E-01,0.7685661316E-02
218,0.3764325753E-01,0.1896223426E-01,0.7059875876E-02
219,0.3694012389E-01,0.1896223426E-01,0.6356740836E-02
220,0.3631433845E-01,0.1896223426E-01,0.5583960097E-02
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*NODE, NSET=NSET2
23302,-.4399999976E-01,-.6938893904E-17,0.4499999806E-02
23303,-.4493560269E-01,-.6938893904E-17,0.4401664250E-02
23304,-.4583031312E-01,-.6938893904E-17,0.4110954702E-02
23305,-.4664503410E-01,-.6938893904E-17,0.3640576499E-02
23306,-.4734415188E-01,-.6938893904E-17,0.3011087654E-02
23307,-.4789711535E-01,-.6938893904E-17,0.2249999903E-02
23308,-.4827975482E-01,-.6938893904E-17,0.1390576479E-02
23309,-.4847534746E-01,-.6938893904E-17,0.4703780869E-03
23310,-.4847534746E-01,-.6938893904E-17,-.4703780869E-03
23311,-.4827975482E-01,-.6938893904E-17,-.1390576479E-02
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
1,0.4399999976E-01,-.6938893904E-17,0.4499999806E-02
2,0.4306439683E-01,-.6938893904E-17,0.4401664250E-02
3,0.4216968641E-01,-.6938893904E-17,0.4110954702E-02
4,0.4135496542E-01,-.6938893904E-17,0.3640576499E-02
5,0.4065584764E-01,-.6938893904E-17,0.3011087654E-02
6,0.4010288417E-01,-.6938893904E-17,0.2249999903E-02
7,0.3972024471E-01,-.6938893904E-17,0.1390576479E-02
8,0.3952465206E-01,-.6938893904E-17,0.4703780869E-03
9,0.3952465206E-01,-.6938893904E-17,-.4703780869E-03
10,0.3972024471E-01,-.6938893904E-17,-.1390576479E-02
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*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*ELEMENT,TYPE=C3D4,ELSET=PART1_EG1
1,3997,3998,3999,4000
2,4000,4001,3998,3999
3,4000,4002,3998,4003
4,4002,4004,4003,4000
5,4000,3999,4005,4006
6,4007,4008,4009,4010
7,4007,4011,4012,4013
8,4007,4014,4008,4010
9,4007,4015,4008,4014
10,4015,4016,4017,4007
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*ELEMENT,TYPE=C3D4,ELSET=PART1_EG2
173413,44386,44387,44388,44389
173414,44386,44390,44388,44387
173415,44391,44392,44393,44386
173416,44394,44395,36254,44396
173417,44397,44398,44399,44387
173418,44398,44400,44401,44387
173419,44386,44393,44388,44402
173420,44386,44392,44393,44402
173421,44386,44390,44397,44403
173422,44386,44391,44404,44393
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,
17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,
33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,
49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,64,
65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,
81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,
97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,
113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,128,
129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,
145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,160,
161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,
177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,192,
193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,208,
209,210,1300,1301,1302,1303,1304,1305,1306,1307,1308,2997,2998,2999,3000,3001,
3002,3003,3004,3005,3483,3484,3485,3486,3487,3488,3489,3490,3491,3492,3493,3494,
3495,3496,3497,3498,3499,3500,3501,3502,3503,3504,3505,3506,3507,3508,3509,3510,
3511,3512,3513,3514,3515,3516,3517,3518,3519,3520,3521,3522,3523,3524,3525,3526,
3527,3528,3529,3530,3531,3532,3533,3534,3535,3536,3537,3538,3539,3540,3541,3542,
3543,3544,3545,3546,3547,3548,3549,3550,3551,3552,3553,3554,
*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
23302,23303,23304,23305,23306,23307,23308,23309,23310,23311,23312,23313,23314,23315,23316,23317,
23318,23319,23320,23321,23322,23323,23324,23325,23326,23327,23328,23329,23330,23331,23332,23333,
23334,23335,23336,23337,23338,23339,23340,23341,23342,23343,23344,23345,23346,23347,23348,23349,
23350,23351,23352,23353,23354,23355,23356,23357,23358,23359,23360,23361,23362,23363,23364,23365,
23366,23367,23368,23369,23370,23371,23372,23373,23374,23375,23376,23377,23378,23379,23380,23381,
23382,23383,23384,23385,23386,23387,23388,23389,23390,23391,23392,23393,23394,23395,23396,23397,
23398,23399,23400,23401,23402,23403,23404,23405,23406,23407,23408,23409,23410,23411,23412,23413,
23414,23415,23416,23417,23418,23419,23420,23421,23422,23423,23424,23425,23426,23427,23428,23429,
23430,23431,23432,23433,23434,23435,23436,23437,23438,23439,23440,23441,23442,23443,23444,23445,
23446,23447,23448,23449,23450,23451,23452,23453,23454,23455,23456,23457,23458,23459,23460,23461,
23462,23463,23464,23465,23466,23467,23468,23469,23470,23471,23472,23473,23474,23475,23476,23477,
23478,23479,23480,23481,23482,23483,23484,23485,23486,23487,23488,23489,23490,23491,23492,23493,
23494,23495,23496,23497,23498,23499,23500,23501,23502,23503,23504,23505,23506,23507,23508,23509,
23510,23511,24801,24802,24803,24804,24805,24806,24807,24808,24809,25303,25304,25305,25306,25307,
25308,25309,25310,25311,25312,25313,25314,25315,25316,25317,25318,25319,25320,25321,25322,25323,
25324,25325,25326,25327,25328,25329,25330,25331,25332,25333,25334,25335,25336,25337,25338,25339,
25340,25341,25342,25343,25344,25345,25346,25347,25348,25349,25350,25351,25352,25353,25354,25355,
25356,25357,25358,25359,25360,25361,25362,25363,25364,25365,25366,25367,25368,25369,25370,25371,
25372,25373,25374,25375,25376,25377,25378,25379,25380,25381,25382,25383,
*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
11899
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
11900
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
11901
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
11902
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
11903
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
11904
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
11905
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
11906
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
11907
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
11908
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
11909
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
11910
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
11911
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
11912
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
11913
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
11914
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
11915
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
11916
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
11917
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
11918
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
11919
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
11920
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
11921
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
11922
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
11923
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
11924
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
11925
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
11926
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
11927
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
11928
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
11929
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
11930
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
11931
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
11932
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
11933
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
11934
*NSET,NSET=CL_NSET37,INSTANCE=PART1-1
11935
*NSET,NSET=CL_NSET38,INSTANCE=PART1-1
11936
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,1,1
ASSEMBLY.BC_NSET2,2,2
ASSEMBLY.BC_NSET2,3,3
*CLOAD,OP=NEW
CL_NSET1,1,-0.817065E+00
*CLOAD,OP=NEW
CL_NSET2,1,-0.142971E+01
*CLOAD,OP=NEW
CL_NSET3,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET4,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET5,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET6,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET7,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET8,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET9,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET10,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET11,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET12,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET13,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET14,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET15,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET16,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET17,1,-0.142971E+01
*CLOAD,OP=NEW
CL_NSET18,1,-0.817065E+00
*CLOAD,OP=NEW
CL_NSET19,1,-0.449151E+01
*CLOAD,OP=NEW
CL_NSET20,1,-0.367388E+01
*CLOAD,OP=NEW
CL_NSET21,1,-0.367388E+01
*CLOAD,OP=NEW
CL_NSET22,1,-0.306157E+01
*CLOAD,OP=NEW
CL_NSET23,1,-0.367388E+01
*CLOAD,OP=NEW
CL_NSET24,1,-0.367388E+01
*CLOAD,OP=NEW
CL_NSET25,1,-0.387920E+01
*CLOAD,OP=NEW
CL_NSET26,1,-0.817065E+00
*CLOAD,OP=NEW
CL_NSET27,1,-0.142971E+01
*CLOAD,OP=NEW
CL_NSET28,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET29,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET30,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET31,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET32,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET33,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET34,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET35,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET36,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET37,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET38,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET39,1,-0.122574E+01
*CLOAD,OP=NEW
CL_NSET40,1,-0.122574E+01
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*END STEP
