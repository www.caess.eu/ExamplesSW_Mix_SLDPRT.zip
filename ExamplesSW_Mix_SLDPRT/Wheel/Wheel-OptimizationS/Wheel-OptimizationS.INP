** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,0.1600000076E-01,0.000000000,-.9999999776E-02
2,0.1593370922E-01,-.1454957761E-02,-.9999999776E-02
3,0.1573538780E-01,-.2897859318E-02,-.9999999776E-02
4,0.1540667657E-01,-.4316748120E-02,-.9999999776E-02
5,0.1495030150E-01,-.5699867383E-02,-.9999999776E-02
6,0.1437004283E-01,-.7035755552E-02,-.9999999776E-02
7,0.1367071085E-01,-.8313342929E-02,-.9999999776E-02
8,0.1285809744E-01,-.9522044100E-02,-.9999999776E-02
9,0.1193893887E-01,-.1065184176E-01,-.9999999776E-02
10,0.1092085056E-01,-.1169337519E-01,-.9999999776E-02
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*NODE, NSET=NSET2
175969,0.6250000093E-02,-.1082531735E-01,0.000000000
175970,0.4950996954E-02,-.1147770137E-01,0.000000000
175971,0.3585040336E-02,-.1197486930E-01,0.000000000
175972,0.2170602325E-02,-.1231009699E-01,0.000000000
175973,0.7268103654E-03,-.1247885171E-01,0.000000000
175974,-.7268103654E-03,-.1247885171E-01,0.000000000
175975,-.2170602325E-02,-.1231009699E-01,0.000000000
175976,-.3585040336E-02,-.1197486930E-01,0.000000000
175977,-.4950996954E-02,-.1147770137E-01,0.000000000
175978,-.6250000093E-02,-.1082531735E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
175944,-.1250000019E-01,0.1530808462E-17,0.9999999776E-02
175945,-.1241547987E-01,-.1451161457E-02,0.9999999776E-02
175946,-.1216306072E-01,-.2882698318E-02,0.9999999776E-02
175947,-.1174615789E-01,-.4275251646E-02,0.9999999776E-02
175948,-.1117040776E-01,-.5609989632E-02,0.9999999776E-02
175949,-.1044359803E-01,-.6868862081E-02,0.9999999776E-02
175950,-.9575555101E-02,-.8034844883E-02,0.9999999776E-02
175951,-.8578020148E-02,-.9092170745E-02,0.9999999776E-02
175952,-.7464482449E-02,-.1002653968E-01,0.9999999776E-02
175953,-.6250000093E-02,-.1082531735E-01,0.9999999776E-02
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*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,7367,7368,7369,7370,124642,124630,124641,124640,124629,124613
2,7370,7371,7372,7368,124599,124592,124598,124629,124628,124627
3,7370,7373,7367,7374,124597,124639,124640,124596,124563,124638
4,7375,7368,7376,7369,124625,124624,124540,124612,124630,124611
5,7368,7376,7369,7370,124624,124611,124630,124629,124595,124613
6,7370,7376,7377,7371,124595,124533,124594,124599,124591,124590
7,7370,7377,7378,7373,124594,124522,124593,124597,124562,124561
8,7379,7380,7381,7382,124505,124493,124504,124503,124492,124482
9,7379,7383,7384,7385,124502,124456,124501,124500,124455,124443
10,7386,7387,7388,7389,124424,124410,124423,124422,124409,124394
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
121024,176588,176124,177009,177010,186254,186252,182942,182941,186251,180431
121025,177010,176124,176221,176123,186251,186255,185595,186258,186262,186261
121026,177010,177011,176227,177012,180423,185555,185556,180422,180418,185554
121027,177010,176221,177009,177013,185595,185596,180431,180421,185594,180430
121028,177010,176227,176123,176221,185556,186260,186258,185595,185597,186261
121029,177014,176389,176265,176945,184393,185206,185203,180751,184394,185204
121030,177014,177015,177016,177017,180399,180392,180398,180397,180391,180387
121031,177014,176941,177015,176938,180766,180765,180399,180781,180783,180780
121032,177014,176889,177018,176942,181085,181084,180396,180763,181086,180762
121033,177019,177014,176889,177018,180395,181085,181083,180374,180396,181084
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
174639,259620,259621,259622,259623,376357,376344,376356,376355,376343,376330
174640,259620,259623,259624,259625,376355,376318,376354,376353,376317,376303
174641,259620,259626,259627,259628,376352,376284,376351,376350,376283,376272
174642,259629,259630,259631,259632,376256,376241,376255,376254,376240,376226
174643,259631,259633,259634,259630,376225,376200,376224,376241,376239,376238
174644,259631,259635,259633,259636,376223,376199,376225,376222,376178,376198
174645,259631,259636,259637,259638,376222,376163,376221,376220,376162,376152
174646,259630,259631,259636,259637,376241,376222,376237,376236,376221,376163
174647,259631,259639,259635,259638,376219,376176,376223,376220,376139,376177
174648,259640,259631,259641,259642,376218,376217,376123,376122,376216,376113
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG3,MATERIAL=MAT3, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
175944,175945,175946,175947,175948,175949,175950,175951,175952,175953,175954,175955,175956,175957,175958,175959,
175960,175961,175962,175963,175964,175965,175966,175967,175968,175988,175989,175990,175991,175992,175993,175994,
175995,175996,175997,175998,175999,176000,176001,176002,176003,176004,176005,176006,176007,176008,176009,176010,
176011,176012,176013,176014,176015,176016,176017,176018,176019,176020,176021,176022,176023,176024,176025,176026,
176027,176028,176029,176030,176031,176032,176033,176034,176035,176036,176037,176038,176039,176040,176041,176042,
176043,176044,176045,176046,176047,176048,176049,176050,176051,176052,176053,176054,176055,176056,176057,176058,
176059,176060,176061,176062,176063,176064,176065,176066,176067,176068,176069,176070,176071,176072,176073,176074,
176075,176076,176077,176078,176079,176080,176081,176082,176083,176084,176085,176086,176087,176088,176089,176090,
176091,176092,176093,176094,176095,176096,176097,176098,176099,176100,176101,176102,176103,176104,176105,176106,
176107,176108,176109,176110,176111,176112,176113,176114,176115,176116,176117,176118,176119,176138,176139,176140,
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*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
175969,175970,175971,175972,175973,175974,175975,175976,175977,175978,175979,175980,175981,175982,175983,175984,
175985,175986,175987,176120,176121,176122,176123,176124,176125,176126,176127,176128,176129,176130,176131,176132,
176133,176134,176135,176136,176137,176557,176558,176559,176560,176561,176562,176563,176564,176565,176566,176567,
176568,176569,176570,176571,176572,176573,183037,183044,183051,183056,183063,183069,183075,183080,183085,183090,
183095,183100,183105,183110,183115,183120,186175,186180,186187,186193,186199,186206,186213,186221,186228,186235,
186242,186250,186257,186262,186269,186275,186280,186282,187207,187216,187223,187229,187235,187241,187248,187255,
187260,187266,187273,187279,187284,187289,187294,187300,187305,187310,187315,187317,221025,221026,221027,221028,
221029,221030,221031,221032,221033,221034,221035,221036,221037,221038,221039,221040,221041,221042,221043,221044,
221045,221046,221047,221048,221049,221050,221051,221052,221053,221054,221055,221056,221057,221058,221059,221060,
221061,221062,221063,221064,221065,221066,221067,221068,221069,221070,221071,221072,221073,221074,221075,221076,
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*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
188427
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
188428
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
188429
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
188430
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
188431
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
188432
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
188433
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
188434
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
188435
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
188436
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
188437
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
188438
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
188439
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
188440
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
188441
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
188442
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
188443
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
188444
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
188445
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
188446
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
188447
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
188448
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
188449
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
188450
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
188451
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
188452
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
188453
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
188454
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
188455
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
188456
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
188457
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
188458
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
188459
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
188460
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
188461
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
188462
*NSET,NSET=CL_NSET37,INSTANCE=PART1-1
188463
*NSET,NSET=CL_NSET38,INSTANCE=PART1-1
188464
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT3
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,1,1
ASSEMBLY.BC_NSET2,2,2
ASSEMBLY.BC_NSET2,3,3
*CLOAD,OP=NEW
CL_NSET1,1,0.418437E-01
*CLOAD,OP=NEW
CL_NSET1,2,-0.418437E-01
*CLOAD,OP=NEW
CL_NSET1,3,0.355056E-01
*CLOAD,OP=NEW
CL_NSET2,1,0.911558E-01
*CLOAD,OP=NEW
CL_NSET2,2,-0.911558E-01
*CLOAD,OP=NEW
CL_NSET2,3,0.773483E-01
*CLOAD,OP=NEW
CL_NSET3,1,0.836953E-01
*CLOAD,OP=NEW
CL_NSET3,2,-0.836953E-01
*CLOAD,OP=NEW
CL_NSET3,3,0.710179E-01
*CLOAD,OP=NEW
CL_NSET4,1,0.547357E+00
*CLOAD,OP=NEW
CL_NSET4,2,-0.547357E+00
*CLOAD,OP=NEW
CL_NSET4,3,0.464447E+00
*CLOAD,OP=NEW
CL_NSET5,1,0.627361E+00
*CLOAD,OP=NEW
CL_NSET5,2,-0.627361E+00
*CLOAD,OP=NEW
CL_NSET5,3,0.532333E+00
*CLOAD,OP=NEW
CL_NSET6,1,0.627374E+00
*CLOAD,OP=NEW
CL_NSET6,2,-0.627374E+00
*CLOAD,OP=NEW
CL_NSET6,3,0.532345E+00
*CLOAD,OP=NEW
CL_NSET7,1,0.627368E+00
*CLOAD,OP=NEW
CL_NSET7,2,-0.627368E+00
*CLOAD,OP=NEW
CL_NSET7,3,0.532339E+00
*CLOAD,OP=NEW
CL_NSET8,1,0.627374E+00
*CLOAD,OP=NEW
CL_NSET8,2,-0.627374E+00
*CLOAD,OP=NEW
CL_NSET8,3,0.532345E+00
*CLOAD,OP=NEW
CL_NSET9,1,0.547346E+00
*CLOAD,OP=NEW
CL_NSET9,2,-0.547346E+00
*CLOAD,OP=NEW
CL_NSET9,3,0.464438E+00
*CLOAD,OP=NEW
CL_NSET10,1,0.417452E-01
*CLOAD,OP=NEW
CL_NSET10,2,-0.417452E-01
*CLOAD,OP=NEW
CL_NSET10,3,0.354220E-01
*CLOAD,OP=NEW
CL_NSET11,1,0.454686E-01
*CLOAD,OP=NEW
CL_NSET11,2,-0.454686E-01
*CLOAD,OP=NEW
CL_NSET11,3,0.385814E-01
*CLOAD,OP=NEW
CL_NSET12,1,0.208703E-01
*CLOAD,OP=NEW
CL_NSET12,2,-0.208703E-01
*CLOAD,OP=NEW
CL_NSET12,3,0.177090E-01
*CLOAD,OP=NEW
CL_NSET13,1,0.271200E+00
*CLOAD,OP=NEW
CL_NSET13,2,-0.271200E+00
*CLOAD,OP=NEW
CL_NSET13,3,0.230120E+00
*CLOAD,OP=NEW
CL_NSET14,1,0.313690E+00
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*END STEP
