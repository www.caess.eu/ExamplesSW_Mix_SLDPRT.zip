** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
55,0.4399999976E-01,0.1896223426E-01,0.9499999695E-02
56,0.4202483967E-01,0.1896223426E-01,0.9292402305E-02
57,0.4013600200E-01,0.1896223426E-01,0.8678682148E-02
58,0.3841603920E-01,0.1896223426E-01,0.7685661316E-02
59,0.3694012389E-01,0.1896223426E-01,0.6356740836E-02
60,0.3577275947E-01,0.1896223426E-01,0.4749999847E-02
61,0.3496496379E-01,0.1896223426E-01,0.2935661469E-02
62,0.3455204144E-01,0.1896223426E-01,0.9930203669E-03
63,0.3455204144E-01,0.1896223426E-01,-.9930203669E-03
64,0.3496496379E-01,0.1896223426E-01,-.2935661469E-02
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*NODE, NSET=NSET2
3354,-.4399999976E-01,-.6938893904E-17,0.4499999806E-02
3355,-.4583031312E-01,-.6938893904E-17,0.4110954702E-02
3356,-.4734415188E-01,-.6938893904E-17,0.3011087654E-02
3357,-.4827975482E-01,-.6938893904E-17,0.1390576479E-02
3358,-.4847534746E-01,-.6938893904E-17,-.4703780869E-03
3359,-.4789711535E-01,-.6938893904E-17,-.2249999903E-02
3360,-.4789711535E-01,0.1792446943E-02,-.2249999903E-02
3361,-.4789711535E-01,0.3584893886E-02,-.2249999903E-02
3362,-.4789711535E-01,0.5377340596E-02,-.2249999903E-02
3363,-.4789711535E-01,0.7169787772E-02,-.2249999903E-02
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
1,0.4399999976E-01,-.6938893904E-17,0.4499999806E-02
2,0.4216968641E-01,-.6938893904E-17,0.4110954702E-02
3,0.4065584764E-01,-.6938893904E-17,0.3011087654E-02
4,0.3972024471E-01,-.6938893904E-17,0.1390576479E-02
5,0.3952465206E-01,-.6938893904E-17,-.4703780869E-03
6,0.4010288417E-01,-.6938893904E-17,-.2249999903E-02
7,0.4010288417E-01,0.1792446943E-02,-.2249999903E-02
8,0.4010288417E-01,0.3584893886E-02,-.2249999903E-02
9,0.4010288417E-01,0.5377340596E-02,-.2249999903E-02
10,0.4010288417E-01,0.7169787772E-02,-.2249999903E-02
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*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*ELEMENT,TYPE=C3D4,ELSET=PART1_EG1
1,436,911,912,913
2,914,10,915,916
3,914,917,918,919
4,920,914,915,919
5,914,918,917,921
6,917,922,923,924
7,8,920,925,914
8,915,926,9,914
9,927,915,926,9
10,928,929,930,931
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*ELEMENT,TYPE=C3D4,ELSET=PART1_EG2
21319,7071,7072,7073,7074
21320,7071,7075,7076,7072
21321,7071,7072,7077,7075
21322,7071,7078,7079,7080
21323,7071,7072,7081,7080
21324,7081,7082,7083,7071
21325,7084,7085,7086,7087
21326,5367,7088,2621,7089
21327,7090,7084,7085,7086
21328,7084,7091,7092,7093
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,
17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,
33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,
49,50,51,52,53,54,353,354,355,356,732,733,734,735,840,841,
842,843,844,845,846,847,848,849,
*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
3354,3355,3356,3357,3358,3359,3360,3361,3362,3363,3364,3365,3366,3367,3368,3369,
3370,3371,3372,3373,3374,3375,3376,3377,3378,3379,3380,3381,3382,3383,3384,3385,
3386,3387,3388,3389,3390,3391,3392,3393,3394,3395,3396,3397,3398,3399,3400,3401,
3402,3403,3404,3405,3406,3407,3746,3747,3748,3749,3862,3863,3864,3865,3866,3867,
3868,3869,3870,3871,3872,3873,3874,3875,
*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
1723
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
1724
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
1725
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
1726
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
1727
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
1728
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
1729
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
1730
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
1731
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
1732
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
1733
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
1734
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
1735
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
1736
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
1737
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
1738
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
1739
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
1740
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
1741
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
1742
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
1743
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
1744
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
1745
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
1746
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
1747
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
1748
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
1749
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
1750
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
1751
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
1752
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
1753
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
1754
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
1755
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
1756
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
1757
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
1758
*NSET,NSET=CL_NSET37,INSTANCE=PART1-1
1759
*NSET,NSET=CL_NSET38,INSTANCE=PART1-1
1760
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,1,1
ASSEMBLY.BC_NSET2,2,2
ASSEMBLY.BC_NSET2,3,3
*CLOAD,OP=NEW
CL_NSET1,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET2,1,-0.520834E+01
*CLOAD,OP=NEW
CL_NSET3,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET4,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET5,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET6,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET7,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET8,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET9,1,-0.694444E+01
*CLOAD,OP=NEW
CL_NSET10,1,-0.868055E+01
*CLOAD,OP=NEW
CL_NSET11,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET12,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET13,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET14,1,-0.347222E+01
*CLOAD,OP=NEW
CL_NSET15,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET16,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET17,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET18,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET19,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET20,1,-0.520833E+01
*CLOAD,OP=NEW
CL_NSET21,1,-0.694445E+01
*CLOAD,OP=NEW
CL_NSET22,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET23,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET24,1,-0.868056E+01
*CLOAD,OP=NEW
CL_NSET25,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET26,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET27,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET28,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET29,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET30,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET31,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET32,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET33,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET34,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET35,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET36,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET37,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET38,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET39,1,-0.104167E+02
*CLOAD,OP=NEW
CL_NSET40,1,-0.104167E+02
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*END STEP
