** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,-.6524470448E-01,0.9487911314E-01,0.1000000047E-02
34,-.4399999976E-01,0.1099950969,0.1000000047E-02
35,-.4403019324E-01,0.1090126112,0.1000000047E-02
36,-.4412065819E-01,0.1080338359,0.1000000047E-02
37,-.4427105933E-01,0.1070624590,0.1000000047E-02
38,-.4448081926E-01,0.1061021537,0.1000000047E-02
39,-.4474915192E-01,0.1051565409,0.1000000047E-02
40,-.4507504776E-01,0.1042291820,0.1000000047E-02
41,-.4545727000E-01,0.1033235937,0.1000000047E-02
42,-.4589437693E-01,0.1024431810,0.1000000047E-02
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*NODE, NSET=NSET2
10459,0.000000000,0.000000000,0.000000000
10460,0.000000000,0.000000000,0.1000000047E-02
10515,0.1000000047E-02,0.1611377318E-20,0.000000000
10516,0.2000000095E-02,0.3222754635E-20,0.000000000
10517,0.3000000026E-02,0.4834131953E-20,0.000000000
10518,0.4000000190E-02,0.6445509271E-20,0.000000000
10519,0.4999999888E-02,0.8056886992E-20,0.000000000
10520,0.6000000052E-02,0.9668263906E-20,0.000000000
10521,0.7000000216E-02,0.1127964163E-19,0.000000000
10522,0.8000000380E-02,0.1289101854E-19,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
2,-.6524470448E-01,0.9487911314E-01,0.000000000
3,-.6430660933E-01,0.9458558261E-01,0.000000000
4,-.6335225701E-01,0.9435021132E-01,0.000000000
5,-.6238524616E-01,0.9417389333E-01,0.000000000
6,-.6140923873E-01,0.9405727684E-01,0.000000000
7,-.6042791158E-01,0.9400082380E-01,0.000000000
8,-.5944497138E-01,0.9400472790E-01,0.000000000
9,-.5846412480E-01,0.9406898171E-01,0.000000000
10,-.5748907477E-01,0.9419334680E-01,0.000000000
11,-.5652350187E-01,0.9437735379E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET3
0.0000E+00,0.1000E+01,0.0000E+00,0.1000E+01,0.0000E+00,0.0000E+00,
*NODE, NSET=NSET4
129,-.6678210944E-01,0.1244865805,0.000000000
130,-.6739787012E-01,0.1241821125,0.000000000
131,-.6800000370E-01,0.1238515005,0.000000000
153,-.5600000173E-01,0.1030668914,0.000000000
154,-.5688171461E-01,0.1026278511,0.000000000
155,-.5781069770E-01,0.1023004949,0.000000000
156,-.5877286568E-01,0.1020897701,0.000000000
157,-.5975363776E-01,0.1019988880,0.000000000
158,-.6073814631E-01,0.1020292267,0.000000000
159,-.6171146408E-01,0.1021803096,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET4
0.0000E+00,0.1000E+01,0.0000E+00,0.1000E+01,0.0000E+00,0.0000E+00,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,146,710,145,1379,9410,9418,9422,9409,5471,9416
2,1380,416,950,399,7613,7616,3945,7730,7732,7731
3,1380,1381,950,949,2017,3944,3945,3949,3948,3952
4,1380,966,415,398,3884,7621,7619,7735,7736,7740
5,1380,966,416,415,3884,7615,7613,7619,7621,7625
6,1380,967,950,416,3881,3946,3945,7613,7614,7616
7,1380,967,966,949,3881,3887,3884,3949,3950,3951
8,1382,1224,656,673,2734,5866,5865,5733,5736,5869
9,1382,1383,1208,657,2014,2794,2795,5858,5857,5860
10,1382,674,657,1225,5728,5862,5858,2731,5729,5859
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
5537,30673,16674,39451,16564,219784,219780,121912,220599,220601,220598
5538,39452,14048,13920,28029,240090,241094,241090,136709,240093,241092
5539,39452,28158,14048,28029,135925,240091,240090,136709,136710,240093
5540,39452,28030,28029,13920,136705,136712,136709,241090,241091,241092
5541,39452,28030,13920,13921,136705,241091,241090,241083,241086,241095
5542,39453,24950,39454,39059,155363,155362,69282,71771,155364,71770
5543,39453,39455,25024,39133,69281,154773,154774,71268,71267,154775
5544,39453,39058,39454,24949,71778,71777,69282,155371,155372,155370
5545,39453,25023,39456,24949,154782,154780,69280,155371,155374,155369
5546,39453,39455,39133,39132,69281,71267,71268,71275,71274,71278
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,
18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,
66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,
82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,
9693,9699,9706,9713,9720,9727,9734,9741,9748,9755,9761,9769,9775,9783,9790,9798,
9805,9811,9817,9825,9831,9836,9842,9849,9855,9862,9869,9876,9882,9888,9893,10045,
10053,10060,10067,10074,10080,10086,10092,10099,10106,10112,10119,10126,10134,10141,10147,10155,
10161,10168,10176,10183,10188,10195,10202,10209,10216,10223,10230,10237,10244,10250,10259,10267,
10268,10269,10270,10271,10272,10273,10274,10275,10276,10277,10278,10279,10280,10281,10282,10283,
10284,10285,10286,10287,10288,10289,10290,10291,10292,10293,10294,10295,10296,10297,10298,10299,
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*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
129,130,131,153,154,155,156,157,158,159,160,161,162,163,164,165,
166,167,168,169,170,188,189,190,191,192,193,194,195,196,197,198,
199,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214,
215,216,217,218,219,220,221,222,223,224,225,226,227,228,229,230,
231,232,233,234,235,236,237,238,273,274,828,829,830,831,832,833,
834,835,836,837,838,839,840,841,842,843,844,845,846,847,848,849,
850,851,852,853,854,855,856,857,858,859,860,861,862,863,864,865,
866,867,868,869,870,871,872,873,874,875,876,877,878,879,880,881,
882,883,884,885,886,887,888,889,890,891,892,893,894,895,896,897,
898,899,900,901,902,903,904,905,906,907,908,909,910,911,912,913,
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*NSET,NSET=BC_NSET3,INSTANCE=PART1-1
10459,10515,10516,10517,10518,10519,10520,10521,10522,10523,10524,10525,10526,10527,10528,10529,
10530,10531,10532,10533,10534,10535,10536,10537,10538,10539,10540,10541,10542,10543,10544,10545,
10546,10547,10548,10549,10550,10551,10552,10553,10554,10555,10556,10557,10558,10559,10560,10561,
10562,10563,10564,10565,10566,10567,10568,10569,10570,10571,10572,10573,10574,10575,10576,10577,
10578,10579,10580,10581,10582,10583,10584,10585,10586,10587,10588,10589,10590,265788,265795,265802,
265809,265816,265823,265830,265837,265844,265851,265858,265865,265872,265879,265886,265893,265900,265907,265914,
265921,265928,265935,265942,265949,265956,265963,265970,265977,265984,265991,265998,266005,266012,266019,266026,
266033,266040,266047,266054,266061,266068,266075,266082,266089,266096,266103,266110,266117,266124,266131,266138,
266145,266152,266159,266166,266173,266180,266187,266194,266201,266208,266215,266222,266229,266236,266243,266250,
266258,266264,266272,266278,266285,266292,266299,266305,266582,
*NSET,NSET=BC_NSET4,INSTANCE=PART1-1
10460,10591,10592,10593,10594,10595,10596,10597,10598,10599,10600,10601,10602,10603,10604,10605,
10606,10607,10608,10609,10610,10611,10612,10613,10614,10615,10616,10617,10618,10619,10620,10621,
10622,10623,10624,10625,10626,10627,10628,10629,10630,10631,10632,10633,10634,10635,10636,10637,
10638,10639,10640,10641,10642,10643,10644,10645,10646,10647,10648,10649,10650,10651,10652,10653,
10654,10655,10656,10657,10658,10659,10660,10661,10662,10663,10664,10665,10666,265408,265413,265418,
265423,265428,265433,265438,265443,265448,265453,265458,265463,265468,265473,265478,265483,265488,265493,265498,
265503,265508,265513,265518,265523,265528,265533,265538,265543,265548,265553,265558,265563,265568,265573,265578,
265583,265588,265593,265598,265603,265608,265613,265618,265623,265628,265633,265638,265643,265648,265653,265658,
265663,265668,265673,265678,265683,265688,265693,265698,265703,265708,265713,265718,265723,265728,265733,265738,
265743,265748,265753,265758,265763,265768,265773,265777,265780,265781,265786,265787,265793,265794,265800,265801,
265807,265808,265814,265815,265821,265822,265828,265829,265835,265836,265842,265843,265849,265850,265856,265857,
265863,265864,265870,265871,265877,265878,265884,265885,265891,265892,265898,265899,265905,265906,265912,265913,
265919,265920,265926,265927,265933,265934,265940,265941,265947,265948,265954,265955,265961,265962,265968,265969,
265975,265976,265982,265983,265989,265990,265996,265997,266003,266004,266010,266011,266017,266018,266024,266025,
266031,266032,266038,266039,266045,266046,266052,266053,266059,266060,266066,266067,266073,266074,266080,266081,
266087,266088,266094,266095,266101,266102,266108,266109,266115,266116,266122,266123,266129,266130,266136,266137,
266143,266144,266150,266151,266157,266158,266164,266165,266171,266172,266178,266179,266185,266186,266192,266193,
266199,266200,266206,266207,266213,266214,266220,266221,266227,266228,266234,266235,266241,266242,266248,266249,
266256,266257,266262,266263,266270,266271,266276,266277,266283,266284,266290,266291,266297,266298,266304,266577,
266578,266584,
*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
153
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
154
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
155
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
156
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
157
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
158
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
159
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
160
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
161
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
162
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
163
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
164
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
165
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
166
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
167
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
168
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
169
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
170
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
188
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
189
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
190
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
191
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
192
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
193
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
194
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
195
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
196
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
197
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
198
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
199
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
200
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
201
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
202
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
203
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
204
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
828
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,3,3
ASSEMBLY.BC_NSET3,3,3
ASSEMBLY.BC_NSET4,1,1
ASSEMBLY.BC_NSET4,2,2
ASSEMBLY.BC_NSET4,3,3
*CLOAD,OP=NEW
CL_NSET1,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET1,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET2,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET2,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET3,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET3,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET4,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET4,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET5,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET5,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET6,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET6,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET7,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET7,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET8,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET8,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET9,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET9,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET10,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET10,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET11,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET11,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET12,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET12,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET13,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET13,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET14,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET14,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET15,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET15,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET16,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET16,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET17,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET17,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET18,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET18,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET19,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET19,2,-0.884369E-14
*CLOAD,OP=NEW
CL_NSET20,1,0.980392E+01
*CLOAD,OP=NEW
CL_NSET20,2,-0.884369E-14
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*END STEP
