** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
101,0.1000000015,0.2500000037E-01,0.1000000047E-02
102,0.9897959232E-01,0.2500000037E-01,0.1000000047E-02
103,0.9795918316E-01,0.2500000037E-01,0.1000000047E-02
104,0.9693877399E-01,0.2500000037E-01,0.1000000047E-02
105,0.9591836482E-01,0.2500000037E-01,0.1000000047E-02
106,0.9489795566E-01,0.2500000037E-01,0.1000000047E-02
107,0.9387755394E-01,0.2500000037E-01,0.1000000047E-02
108,0.9285714477E-01,0.2500000037E-01,0.1000000047E-02
109,0.9183673561E-01,0.2500000037E-01,0.1000000047E-02
110,0.9081632644E-01,0.2500000037E-01,0.1000000047E-02
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*NODE, NSET=NSET2
1,0.000000000,0.2500000037E-01,0.1000000047E-02
2,0.000000000,0.2500000037E-01,0.000000000
47541,0.000000000,0.2500000037E-01,0.4999999655E-03
47542,0.000000000,0.000000000,0.000000000
47739,0.000000000,0.000000000,0.1000000047E-02
47788,0.000000000,0.2400000021E-01,0.000000000
47789,0.000000000,0.2300000004E-01,0.000000000
47790,0.000000000,0.2199999988E-01,0.000000000
47791,0.000000000,0.2099999972E-01,0.000000000
47792,0.000000000,0.1999999955E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
199,0.000000000,0.5000000075E-01,0.000000000
200,0.000000000,0.4899999872E-01,0.000000000
201,0.000000000,0.4800000042E-01,0.000000000
202,0.000000000,0.4699999839E-01,0.000000000
203,0.000000000,0.4600000009E-01,0.000000000
204,0.000000000,0.4500000179E-01,0.000000000
205,0.000000000,0.4399999976E-01,0.000000000
206,0.000000000,0.4300000146E-01,0.000000000
207,0.000000000,0.4199999943E-01,0.000000000
208,0.000000000,0.4100000113E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET4
3,0.1020408119E-02,0.2500000037E-01,0.000000000
4,0.2040816238E-02,0.2500000037E-01,0.000000000
5,0.3061224474E-02,0.2500000037E-01,0.000000000
6,0.4081632476E-02,0.2500000037E-01,0.000000000
7,0.5102040712E-02,0.2500000037E-01,0.000000000
8,0.6122448947E-02,0.2500000037E-01,0.000000000
9,0.7142857183E-02,0.2500000037E-01,0.000000000
10,0.8163264953E-02,0.2500000037E-01,0.000000000
11,0.9183673188E-02,0.2500000037E-01,0.000000000
12,0.1020408142E-01,0.2500000037E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET4
0.0000E+00,0.1000E+01,0.0000E+00,0.1000E+01,0.0000E+00,0.0000E+00,
*NODE, NSET=NSET5
274,0.1000000015,0.2600000054E-01,0.000000000
275,0.1000000015,0.2700000070E-01,0.000000000
276,0.1000000015,0.2800000086E-01,0.000000000
277,0.1000000015,0.2899999917E-01,0.000000000
278,0.1000000015,0.2999999933E-01,0.000000000
279,0.1000000015,0.3099999949E-01,0.000000000
280,0.1000000015,0.3200000152E-01,0.000000000
281,0.1000000015,0.3299999982E-01,0.000000000
282,0.1000000015,0.3400000185E-01,0.000000000
283,0.1000000015,0.3500000015E-01,0.000000000
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*TRANSFORM,TYPE=R,NSET=NSET5
0.0000E+00,0.1000E+01,0.0000E+00,0.1000E+01,0.0000E+00,0.0000E+00,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,4955,4541,82,81,14545,46975,46973,46980,46981,46985
2,4956,4794,93,92,12798,46899,46897,46904,46905,46909
3,4956,4957,4771,2540,11764,12956,12957,28477,28476,28478
4,4958,2770,4959,539,26717,26716,11760,44245,44247,44244
5,4958,2747,4959,2770,26873,26872,11760,26717,26874,26716
6,4960,229,4961,1602,46174,46173,11758,35853,46175,35852
7,4960,229,1602,230,46174,46175,35853,46168,46177,46171
8,4960,3834,230,1603,19379,46169,46168,35847,35848,46170
9,4960,4962,1603,1602,11757,35846,35847,35853,35851,35855
10,4960,4961,3833,1602,11758,19383,19384,35853,35852,35854
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
1,2,47541,47739,47812,47813,47814,47815,47816,47817,47818,47819,47820,47821,47822,47823,
47824,47825,47826,47827,47828,47829,47830,47831,47832,47833,47834,47835,92074,92079,92084,92089,
92094,92099,92103,92106,92109,92113,92117,92120,92124,92129,92133,92137,92142,92147,92152,92157,
92162,92167,92171,92175,92176,92181,92182,92188,92189,92195,92196,92202,92203,92209,92210,92215,
92216,92221,92222,92227,92228,92232,92233,92238,92239,92245,92246,92251,92252,92257,92258,92264,
92265,92271,92272,92277,92278,92283,92284,92290,92291,92297,92298,92304,92305,92311,92312,92317,
92318,92324,92586,93762,93764,94557,94561,
*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,
19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,
35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,
51,52,53,54,55,56,57,58,59,60,61,62,63,64,65,66,
67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,
83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,
99,100,46860,46867,46874,46881,46888,46896,46902,46909,46916,46923,46931,46937,46944,46951,
46958,46965,46972,46978,46985,46992,46999,47006,47013,47020,47027,47034,47041,47048,47055,47062,
47069,47077,47083,47090,47097,47104,47111,47118,47125,47132,47139,47147,47153,47160,47167,47174,
47181,47188,47195,47202,47209,47216,47223,47230,47237,47245,47251,47258,47265,47272,47279,47286,
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*NSET,NSET=BC_NSET3,INSTANCE=PART1-1
199,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214,
215,216,217,218,219,220,221,222,223,46213,46220,46227,46234,46241,46247,46252,
46258,46264,46269,46274,46279,46285,46292,46299,46305,46311,46318,46325,46332,46339,46346,46353,
46358,47534,
*NSET,NSET=BC_NSET4,INSTANCE=PART1-1
224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239,
240,241,242,243,244,245,246,247,248,46095,46100,46105,46110,46115,46120,46125,
46129,46132,46135,46139,46144,46149,46154,46158,46162,46167,46172,46177,46182,46187,46192,46196,
46201,46205,46206,46211,46212,46218,46219,46225,46226,46232,46233,46239,46240,46245,46246,46250,
46251,46256,46257,46262,46263,46267,46268,46272,46273,46277,46278,46283,46284,46290,46291,46297,
46298,46303,46304,46309,46310,46316,46317,46323,46324,46330,46331,46337,46338,46344,46345,46351,
46352,46357,47533,47539,
*NSET,NSET=BC_NSET5,INSTANCE=PART1-1
274,275,276,277,278,279,280,281,282,283,284,285,286,287,288,289,
290,291,292,293,294,295,296,297,298,299,300,301,302,303,304,305,
306,307,308,309,310,311,312,313,314,315,316,317,318,319,320,321,
322,323,324,325,326,327,328,329,330,331,332,333,334,335,336,337,
338,339,340,341,342,343,344,345,346,347,348,349,350,351,352,353,
354,355,356,357,358,359,360,361,362,363,364,365,366,367,368,369,
370,371,372,373,374,375,376,377,378,379,380,381,382,383,384,385,
386,387,388,389,390,391,392,393,394,395,2724,2725,2726,2727,2728,2729,
2730,2731,2732,2733,2734,2735,2736,2737,2738,2739,2740,2741,2742,2743,2744,2745,
2746,2747,2748,2749,2750,2751,2752,2753,2754,2755,2756,2757,2758,2759,2760,2761,
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*NSET,NSET=BC_NSET6,INSTANCE=PART1-1
47542,47788,47789,47790,47791,47792,47793,47794,47795,47796,47797,47798,47799,47800,47801,47802,
47803,47804,47805,47806,47807,47808,47809,47810,47811,92183,92190,92197,92204,92211,92217,92223,
92229,92234,92240,92247,92253,92259,92266,92273,92279,92285,92292,92299,92306,92313,92319,92325,
93763,94558,
*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
100
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
101
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
46853
*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,3,3
ASSEMBLY.BC_NSET3,3,3
ASSEMBLY.BC_NSET4,1,1
ASSEMBLY.BC_NSET4,2,2
ASSEMBLY.BC_NSET4,3,3
ASSEMBLY.BC_NSET5,3,3
ASSEMBLY.BC_NSET6,3,3
*CLOAD,OP=NEW
CL_NSET1,1,-0.666667E+02
*CLOAD,OP=NEW
CL_NSET2,2,-0.666667E+02
*CLOAD,OP=NEW
CL_NSET3,2,-0.666667E+02
*END STEP
