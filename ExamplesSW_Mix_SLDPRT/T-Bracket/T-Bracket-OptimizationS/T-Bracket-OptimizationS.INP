** Output from COS2ABQ translator version 2014
*HEADING

** PARTS
**
*PART,NAME=PART1
*NODE, NSET=NSET1
1,0.9549999982E-01,0.1279422827E-01,0.4999999888E-02
2,0.9384761006E-01,0.1156872232E-01,0.4999999888E-02
3,0.9251668304E-01,0.9999999776E-02,0.4999999888E-02
4,0.9501112252E-01,0.9999999776E-02,0.4999999888E-02
5,0.9750556201E-01,0.9999999776E-02,0.4999999888E-02
6,0.1000000015,0.9999999776E-02,0.4999999888E-02
7,0.1000000015,0.8500000462E-02,0.4999999888E-02
8,0.1017500013,0.8031088859E-02,0.4999999888E-02
9,0.1030310914,0.6750000175E-02,0.4999999888E-02
10,0.1035000011,0.4999999888E-02,0.4999999888E-02
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*NODE, NSET=NSET2
64106,0.3500000108E-02,0.4999999888E-02,0.3500000015E-01
80701,0.3500000108E-02,0.4999999888E-02,0.5000000075E-01
80702,0.3500000108E-02,0.4999999888E-02,0.4749999940E-01
80703,0.3500000108E-02,0.4999999888E-02,0.4500000179E-01
80704,0.3500000108E-02,0.4999999888E-02,0.4250000045E-01
80705,0.3500000108E-02,0.4999999888E-02,0.3999999911E-01
80706,0.3500000108E-02,0.4999999888E-02,0.3750000149E-01
81342,0.3500000108E-02,0.4999999888E-02,0.3874999657E-01
81350,0.3500000108E-02,0.4999999888E-02,0.4125000164E-01
81359,0.3500000108E-02,0.4999999888E-02,0.4374999925E-01
81369,0.3500000108E-02,0.4999999888E-02,0.4624999687E-01
81373,0.3500000108E-02,0.4999999888E-02,0.4875000194E-01
81455,0.3500000108E-02,0.4999999888E-02,0.3624999896E-01
*TRANSFORM,TYPE=R,NSET=NSET2
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET3
1973,0.3500000108E-02,0.4999999888E-02,-.3500000015E-01
82649,0.3500000108E-02,0.4999999888E-02,-.3750000149E-01
82650,0.3500000108E-02,0.4999999888E-02,-.3999999911E-01
82651,0.3500000108E-02,0.4999999888E-02,-.4250000045E-01
82652,0.3500000108E-02,0.4999999888E-02,-.4500000179E-01
82653,0.3500000108E-02,0.4999999888E-02,-.4749999940E-01
82654,0.3500000108E-02,0.4999999888E-02,-.5000000075E-01
83092,0.3500000108E-02,0.4999999888E-02,-.4874999821E-01
83100,0.3500000108E-02,0.4999999888E-02,-.4625000060E-01
83109,0.3500000108E-02,0.4999999888E-02,-.4374999925E-01
83118,0.3500000108E-02,0.4999999888E-02,-.4125000164E-01
83127,0.3500000108E-02,0.4999999888E-02,-.3875000030E-01
83129,0.3500000108E-02,0.4999999888E-02,-.3624999896E-01
*TRANSFORM,TYPE=R,NSET=NSET3
0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,0.1000E+01,0.0000E+00,
*NODE, NSET=NSET4
65056,-.3500000108E-02,0.9099999815E-01,-.4999999888E-02
65061,-.3500000108E-02,0.9099999815E-01,0.4999999888E-02
65062,-.3500000108E-02,0.9099999815E-01,0.2499999944E-02
65063,-.3500000108E-02,0.9099999815E-01,0.000000000
65064,-.3500000108E-02,0.9099999815E-01,-.2499999944E-02
65512,-.3500000108E-02,0.9099999815E-01,-.1250000787E-02
65521,-.3500000108E-02,0.9099999815E-01,0.1249998226E-02
65523,-.3500000108E-02,0.9099999815E-01,0.3749999683E-02
65548,-.3500000108E-02,0.9099999815E-01,-.3750000382E-02
*TRANSFORM,TYPE=R,NSET=NSET4
0.0000E+00,0.1000E+01,0.0000E+00,0.0000E+00,0.0000E+00,-.1000E+01,
*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,216,217,218,219,668,660,667,666,659,655
2,219,220,130,127,648,1167,1168,1185,1184,1190
3,219,130,221,216,1168,1166,647,666,1169,665
4,219,129,220,222,1174,1173,648,646,1171,640
5,219,223,189,224,645,817,818,644,623,816
6,222,225,219,221,626,643,646,633,632,647
7,219,225,224,189,643,616,644,818,815,816
8,226,227,228,223,606,603,605,622,621,620
9,227,228,124,226,603,1208,1209,606,605,1210
10,113,229,230,231,1272,590,1271,1270,589,586
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
1122,2082,1980,1987,1986,2741,2744,2701,2706,2745,2707
1123,2083,2084,1989,2085,2188,2688,2689,2187,2183,2687
1124,2085,1961,2084,1989,2869,2870,2183,2687,2874,2688
1125,2085,2076,2086,2087,2218,2217,2179,2178,2216,2177
1126,2085,2086,1990,2087,2179,2683,2684,2178,2177,2682
1127,2085,1960,2075,1961,2877,2879,2221,2869,2882,2871
1128,2085,1960,2086,2076,2877,2876,2179,2218,2878,2217
1129,2088,1969,2089,2080,2814,2813,2176,2199,2816,2198
1130,2090,2088,1995,2091,2175,2660,2659,2168,2174,2658
1131,2088,2092,1995,1970,2173,2657,2660,2807,2806,2810
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
1615,6645,6646,6647,6648,37920,37906,37919,37918,37905,37896
1616,6645,6649,6650,6651,37917,37868,37916,37915,37867,37854
1617,6645,6649,6652,6650,37917,37866,37914,37916,37868,37853
1618,6653,6645,6646,6647,37913,37920,37904,37894,37919,37906
1619,4757,4676,6654,4760,51413,51409,50885,50888,51412,50866
1620,6655,6656,6657,6658,37815,37800,37814,37813,37799,37790
1621,6655,6658,6601,6659,37813,38169,38170,37812,37776,38168
1622,6655,6601,6658,6660,38170,38169,37813,37811,38167,37775
1623,6655,6661,6662,6663,37810,37754,37809,37808,37753,37745
1624,6664,6665,5363,6666,37729,46527,46528,37728,37720,46526
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
41887,64225,64226,64227,64134,64314,64310,64313,64816,64815,64814
41888,64225,64218,64228,64229,64346,64344,64312,64311,64343,64304
41889,64225,64135,64228,64226,64811,64809,64312,64314,64810,64309
41890,64225,64129,64229,64135,64840,64839,64311,64811,64844,64808
41891,64225,64218,64129,64128,64346,64842,64840,64847,64848,64852
41892,64230,64214,64231,64232,64366,64365,64300,64299,64364,64296
41893,64230,64231,64233,64131,64300,64295,64298,64831,64830,64828
41894,64230,64125,64232,64131,64868,64867,64299,64831,64872,64829
41895,64230,64233,64234,64137,64298,64291,64297,64801,64800,64799
41896,64230,64214,64125,64124,64366,64870,64868,64875,64877,64880
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
42365,65100,65074,65069,65052,65444,65479,65476,65568,65569,65571
42366,65100,65101,4620,4623,65316,65709,65710,65697,65696,51849
42367,65100,65102,65103,65055,65315,65306,65314,65554,65553,65552
42368,65100,65104,65103,65102,65313,65300,65314,65315,65305,65306
42369,65100,65105,65101,4623,65312,65309,65316,65697,65695,65696
42370,65100,65102,65084,65083,65315,65392,65393,65399,65398,65401
42371,65106,65107,65108,65109,65291,65286,65290,65289,65285,65277
42372,65108,65110,65065,65109,65276,65495,65497,65277,65273,65496
42373,65036,65106,65029,65109,65793,65836,65840,65791,65289,65835
42374,65035,65111,65112,65092,65799,65268,65798,65801,65351,65350
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
42950,66042,66043,66017,66020,66381,66513,66514,66501,66500,66516
42951,66017,66042,66044,66043,66514,66380,66512,66513,66381,66371
42952,66042,66045,66046,66047,66379,66355,66378,66377,66354,66343
42953,66042,66048,66019,66049,66376,66505,66506,66375,66327,66504
42954,66042,66050,66020,66051,66374,66499,66501,66373,66321,66498
42955,66052,66053,66028,66029,66313,66456,66457,66450,66449,66459
42956,66052,66053,66029,66054,66313,66449,66450,66312,66303,66448
42957,66055,66056,66057,66058,66292,66283,66291,66290,66282,66273
42958,66055,66056,66059,66057,66292,66281,66289,66291,66283,66272
42959,66055,66058,66046,66056,66290,66339,66341,66292,66282,66340
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
51580,79895,79896,79881,79882,80098,80160,80161,80156,80155,80164
51581,79895,79897,79898,79899,80097,80083,80096,80095,80082,80074
51582,79895,79882,79900,79896,80156,80154,80094,80098,80155,80091
51583,79895,79898,79900,79873,80096,80073,80094,80202,80201,80199
51584,79901,65073,79902,65070,80362,80361,80063,80371,65474,80370
51585,79903,79902,79892,79901,80058,80107,80106,80062,80063,80108
51586,79856,79854,79904,65057,80307,80306,80297,80438,80439,80437
51587,79901,79861,65050,65049,80274,80381,80378,80374,80376,65590
51588,79901,79905,79864,79861,80061,80257,80258,80274,80273,80276
51589,79842,79906,79907,79897,80455,80045,80454,80458,80080,80079
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
54562,84788,84789,84790,84758,85402,85395,85401,85569,85568,85567
54563,84788,84755,84790,84791,85587,85586,85401,85400,85585,85386
54564,84788,84792,84793,84794,85399,85370,85398,85397,85369,85363
54565,84788,84791,84754,84755,85400,85593,85594,85587,85585,85596
54566,84788,84792,84754,84791,85399,85592,85594,85400,85380,85593
54567,84790,84795,84796,84797,85385,85351,85384,85383,85350,85340
54568,84788,84797,84790,84789,85396,85383,85401,85402,85391,85395
54569,84790,84797,84796,84789,85383,85340,85384,85395,85391,85392
54570,84762,84789,84759,84798,85547,85564,85565,85545,85390,85562
54571,84789,84759,84798,84790,85564,85562,85390,85395,85563,85382
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG3
76437,116312,4641,116313,116314,116393,116392,116358,116357,116391,116353
76438,116312,116315,4641,3079,116356,116390,116393,116512,116511,62833
76439,116312,64154,116315,3079,116514,116513,116356,116512,64694,116511
76440,116312,4641,4642,3078,116393,51598,116389,116460,62840,62839
76441,116312,116316,4642,116314,116355,116387,116389,116357,116348,116388
76442,116308,116317,116305,116316,116407,116433,116439,116408,116343,116434
76443,116312,116317,3078,4642,116354,116459,116460,116389,116386,62839
76444,2908,116081,116318,116319,116493,116470,116492,116491,116469,116340
76445,2898,2908,116300,2899,64102,116540,116558,64103,64096,116556
76446,2908,116300,2899,116319,116540,116556,64096,116491,116538,116555
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG2
76671,116635,1960,116636,1990,117223,117222,116724,117132,2881,117131
76672,116635,116637,116636,101468,116723,116721,116724,116745,116743,116744
76673,116635,1961,116638,101467,117221,117220,116722,116749,116007,116747
76674,116635,101467,1960,1961,116749,116002,117223,117221,116007,2882
76675,116635,116637,116638,1989,116723,116719,116722,117136,117135,117134
76676,116639,116640,101469,116641,116714,116740,116741,116713,116710,116739
76677,116639,116640,1966,101469,116714,117210,117211,116741,116740,116039
76678,116639,101470,1966,1967,116737,116038,117211,117209,116046,2840
76679,116639,116642,101470,1967,116712,116736,116737,117209,117208,116046
76680,116639,116643,116642,1992,116711,116705,116712,117124,117122,117123
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*ORIENTATION,NAME=RECT1,DEFINITION=COORDINATES,SYSTEM=RECTANGULAR
1.0,0.0,0.0,0.0,1.0,0.0
0.0,0.0,0.0
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG2,MATERIAL=MAT2, ORIENT=RECT1
*SOLID SECTION,ELSET=PART1_EG3,MATERIAL=MAT3, ORIENT=RECT1
*END PART
** ASSEMBLY
*ASSEMBLY, NAME=ASSEMBLY
*INSTANCE, NAME=PART1-1, PART=PART1
*END INSTANCE
*NSET,NSET=BC_NSET1,INSTANCE=PART1-1
1973,82649,82650,82651,82652,82653,82654,83092,83100,83109,83118,83127,83129,
*NSET,NSET=BC_NSET2,INSTANCE=PART1-1
64106,80701,80702,80703,80704,80705,80706,81342,81350,81359,81369,81373,81455,
*NSET,NSET=BC_NSET3,INSTANCE=PART1-1
65056,65061,65062,65063,65064,65512,65521,65523,65548,
*NSET,NSET=CL_NSET1,INSTANCE=PART1-1
7
*NSET,NSET=CL_NSET2,INSTANCE=PART1-1
8
*NSET,NSET=CL_NSET3,INSTANCE=PART1-1
9
*NSET,NSET=CL_NSET4,INSTANCE=PART1-1
10
*NSET,NSET=CL_NSET5,INSTANCE=PART1-1
11
*NSET,NSET=CL_NSET6,INSTANCE=PART1-1
12
*NSET,NSET=CL_NSET7,INSTANCE=PART1-1
13
*NSET,NSET=CL_NSET8,INSTANCE=PART1-1
51
*NSET,NSET=CL_NSET9,INSTANCE=PART1-1
52
*NSET,NSET=CL_NSET10,INSTANCE=PART1-1
53
*NSET,NSET=CL_NSET11,INSTANCE=PART1-1
54
*NSET,NSET=CL_NSET12,INSTANCE=PART1-1
55
*NSET,NSET=CL_NSET13,INSTANCE=PART1-1
56
*NSET,NSET=CL_NSET14,INSTANCE=PART1-1
135
*NSET,NSET=CL_NSET15,INSTANCE=PART1-1
136
*NSET,NSET=CL_NSET16,INSTANCE=PART1-1
137
*NSET,NSET=CL_NSET17,INSTANCE=PART1-1
138
*NSET,NSET=CL_NSET18,INSTANCE=PART1-1
139
*NSET,NSET=CL_NSET19,INSTANCE=PART1-1
140
*NSET,NSET=CL_NSET20,INSTANCE=PART1-1
141
*NSET,NSET=CL_NSET21,INSTANCE=PART1-1
142
*NSET,NSET=CL_NSET22,INSTANCE=PART1-1
143
*NSET,NSET=CL_NSET23,INSTANCE=PART1-1
144
*NSET,NSET=CL_NSET24,INSTANCE=PART1-1
145
*NSET,NSET=CL_NSET25,INSTANCE=PART1-1
146
*NSET,NSET=CL_NSET26,INSTANCE=PART1-1
147
*NSET,NSET=CL_NSET27,INSTANCE=PART1-1
148
*NSET,NSET=CL_NSET28,INSTANCE=PART1-1
149
*NSET,NSET=CL_NSET29,INSTANCE=PART1-1
150
*NSET,NSET=CL_NSET30,INSTANCE=PART1-1
151
*NSET,NSET=CL_NSET31,INSTANCE=PART1-1
152
*NSET,NSET=CL_NSET32,INSTANCE=PART1-1
153
*NSET,NSET=CL_NSET33,INSTANCE=PART1-1
154
*NSET,NSET=CL_NSET34,INSTANCE=PART1-1
155
*NSET,NSET=CL_NSET35,INSTANCE=PART1-1
156
*NSET,NSET=CL_NSET36,INSTANCE=PART1-1
157
*NSET,NSET=CL_NSET37,INSTANCE=PART1-1
158
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT2
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*MATERIAL,NAME=MAT3
*ELASTIC
0.200000E+10,0.394000E+00,
*PLASTIC
0.20000E+08,0.0000,0.0000
*DENSITY
0.102000E+04,
*CONDUCTIVITY
0.225600E+00,
*SPECIFIC HEAT
0.138600E+04,
*STEP,SOLVER=ITERATIVE
LOAD CASE NUMBER 1
*STATIC
*BOUNDARY
ASSEMBLY.BC_NSET1,1,1
ASSEMBLY.BC_NSET1,2,2
ASSEMBLY.BC_NSET1,3,3
ASSEMBLY.BC_NSET2,1,1
ASSEMBLY.BC_NSET2,2,2
ASSEMBLY.BC_NSET2,3,3
ASSEMBLY.BC_NSET3,3,3
*CLOAD,OP=NEW
CL_NSET1,2,-0.143047E-01
*CLOAD,OP=NEW
CL_NSET2,2,-0.117278E-01
*CLOAD,OP=NEW
CL_NSET3,2,-0.143074E-01
*CLOAD,OP=NEW
CL_NSET4,2,-0.156738E-01
*CLOAD,OP=NEW
CL_NSET5,2,-0.143097E-01
*CLOAD,OP=NEW
CL_NSET6,2,-0.117246E-01
*CLOAD,OP=NEW
CL_NSET7,2,-0.143048E-01
*CLOAD,OP=NEW
CL_NSET8,2,-0.143167E-01
*CLOAD,OP=NEW
CL_NSET9,2,-0.262319E-01
*CLOAD,OP=NEW
CL_NSET10,2,-0.369207E-01
*CLOAD,OP=NEW
CL_NSET11,2,-0.369232E-01
*CLOAD,OP=NEW
CL_NSET12,2,-0.263637E-01
*CLOAD,OP=NEW
CL_NSET13,2,-0.143163E-01
*CLOAD,OP=NEW
CL_NSET14,2,-0.694996E-01
*CLOAD,OP=NEW
CL_NSET15,2,-0.738397E-01
*CLOAD,OP=NEW
CL_NSET16,2,-0.696241E-01
*CLOAD,OP=NEW
CL_NSET17,2,-0.262418E-01
*CLOAD,OP=NEW
CL_NSET18,2,-0.654178E-01
*CLOAD,OP=NEW
CL_NSET19,2,-0.737159E-01
*CLOAD,OP=NEW
CL_NSET20,2,-0.652893E-01
*CLOAD,OP=NEW
CL_NSET21,2,-0.156717E-01
*CLOAD,OP=NEW
CL_NSET22,2,-0.143182E-01
*CLOAD,OP=NEW
CL_NSET23,2,-0.117215E-01
*CLOAD,OP=NEW
CL_NSET24,2,-0.739829E-01
*CLOAD,OP=NEW
CL_NSET25,2,-0.738452E-01
*CLOAD,OP=NEW
CL_NSET26,2,-0.664379E-01
*CLOAD,OP=NEW
CL_NSET27,2,-0.665606E-01
*CLOAD,OP=NEW
CL_NSET28,2,-0.665699E-01
*CLOAD,OP=NEW
CL_NSET29,2,-0.665570E-01
*CLOAD,OP=NEW
CL_NSET30,2,-0.696223E-01
*CLOAD,OP=NEW
CL_NSET31,2,-0.738390E-01
*CLOAD,OP=NEW
CL_NSET32,2,-0.694988E-01
*CLOAD,OP=NEW
CL_NSET33,2,-0.263712E-01
*CLOAD,OP=NEW
CL_NSET34,2,-0.369201E-01
*CLOAD,OP=NEW
CL_NSET35,2,-0.369169E-01
*CLOAD,OP=NEW
CL_NSET36,2,-0.738413E-01
*CLOAD,OP=NEW
CL_NSET37,2,-0.738427E-01
*CLOAD,OP=NEW
CL_NSET38,2,-0.738478E-01
*CLOAD,OP=NEW
CL_NSET39,2,-0.738498E-01
*CLOAD,OP=NEW
CL_NSET40,2,-0.738451E-01
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*END STEP
